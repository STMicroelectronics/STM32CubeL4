# Keil uVision project Project.uvprojx, settings and files
target STM32L452RE_NUCLEO (ARM-ADS)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.2
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L452RE_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L452xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_usart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash.c stm32l4xx_hal_spi.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_uart.c stm32l4xx_ll_usb.c stm32l4xx_hal_gpio.c
  group Application/User
    ../Src/: usbd_cdc_interface.c stm32l4xx_hal_msp.c main.c usbd_desc.c usbd_conf.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l452xx.s
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
software components: CMSIS:CORE 4.3.0
