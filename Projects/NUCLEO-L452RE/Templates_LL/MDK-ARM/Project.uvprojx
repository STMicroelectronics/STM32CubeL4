# Keil uVision project Project.uvprojx, settings and files
target STM32L452RE_NUCLEO (6140000::V6.14::ARMCLANG)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L452RE_NUCLEO
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32L452xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Example/User
    ../Src/: stm32l4xx_it.c main.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L4xx_LL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_tim.c stm32l4xx_ll_rng.c stm32l4xx_ll_i2c.c stm32l4xx_ll_adc.c stm32l4xx_ll_dma.c stm32l4xx_ll_exti.c stm32l4xx_ll_spi.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_rtc.c stm32l4xx_ll_pwr.c stm32l4xx_ll_dac.c stm32l4xx_ll_crs.c stm32l4xx_ll_utils.c stm32l4xx_ll_crc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_lptim.c stm32l4xx_ll_opamp.c stm32l4xx_ll_comp.c stm32l4xx_ll_rcc.c stm32l4xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/MDK-ARM
    ./: startup_stm32l452xx.s
software components: CMSIS:CORE 5.4.0
