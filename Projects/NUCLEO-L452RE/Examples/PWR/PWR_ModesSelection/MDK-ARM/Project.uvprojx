# Keil uVision project Project.uvprojx, settings and files
target STM32L452RE_NUCLEO (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L452RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.2
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L452RE_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L452xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Example/User
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c main.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_uart_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal.c stm32l4xx_hal_uart.c stm32l4xx_hal_gpio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/MDK-ARM
    ./: startup_stm32l452xx.s
  group Example/User/TestConso
    ../Src/: standby_rtc_sram2_test.c sleep_range2_test.c run_range1_test.c stop1_mroff_test.c standby_test.c lpsleep_test.c standby_rtc_test.c stop2_rtc_test.c stop2_test.c lprun_test.c run_range2_test.c shutdown_test.c stop1_mroff_rtc_test.c sleep_range1_test .c
software components: CMSIS:CORE 4.3.0
