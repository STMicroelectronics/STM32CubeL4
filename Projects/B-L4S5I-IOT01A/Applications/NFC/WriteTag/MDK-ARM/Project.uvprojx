# Keil uVision project Project.uvprojx, settings and files
target IOT_NFC_WriteTag (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4S5ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.3
  cpu: IRAM(0x20000000,0x000A0000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32L4S5xx,USE_HAL_DRIVER,USE_STM32L4S5I_IOT01
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L4S5I-IOT01;../../../../../../Drivers/BSP/Components/ST25DV;../../Common/lib_nfc/lib_NDEF/Core/inc;../../Common/lib_nfc/common/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/Common/lib_nfc
    ../../Common/lib_nfc/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_SMS.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c tagtype5_wrapper.c
  group Application/MDK-ARM
    ./: startup_stm32l4s5xx.s
  group Application/User
    ../Src/: lib_NDEF_config.c main.c stm32l4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c st25dv_reg.c
  group Drivers/BSP/STM32L4S5x_IoT_Discovery
    ../../../../../../Drivers/BSP/B-L4S5I-IOT01/: stm32l4s5i_iot01.c stm32l4s5i_iot01_nfctag.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
software components: CMSIS:CORE 5.3.0
