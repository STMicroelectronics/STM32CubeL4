# Keil uVision project Project.uvprojx, settings and files
target B-L4S5I-IOT01_WiFi_HTTP_Server (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4S5ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.3
  cpu: IRAM(0x20000000,0x000A0000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32L4S5xx,USE_HAL_DRIVER,USE_STM32L4S5I_IOT01
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L4S5I-IOT01;../../../../../../Drivers/BSP/Components/Common;../../Common/Inc;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  scatter file: Project.sct
  group Application/WiFi
    ../../Common/Src/: es_wifi.c es_wifi_io.c wifi.c
  group Application/User
    ../Src/: main.c flash_l4.c stm32l4xx_it.c system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l4s5xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/B-L4S5I-IOT01/: stm32l4s5i_iot01.c stm32l4s5i_iot01_tsensor.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
software components: CMSIS:CORE 5.3.0
