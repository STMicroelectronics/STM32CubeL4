# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery (ARM-ADS)
  device: STM32L496AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496G-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Doc
    ../: readme.txt
  group Drivers/STM32L4xx_LL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c
  group Example/User
    ../Src/: stm32l4xx_it.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/MDK-ARM
    ./: startup_stm32l496xx.s
software components: CMSIS:CORE 4.3.0
