# Keil uVision project Project.uvprojx, settings and files
target STM32L496G-Discovery (ARM-ADS)
  device: STM32L4A6ZGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496G-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L496G-Discovery
  library: MicroLIB
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery_lcd.c stm32l496g_discovery.c stm32l496g_discovery_io.c
  group Example/User
    ../Src/: stm32l4xx_it.c stm32l4xx_hal_msp.c main.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_sram.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/MDK-ARM
    ./: startup_stm32l496xx.s
software components: CMSIS:CORE 4.3.0
