# Keil uVision project Project.uvprojx, settings and files
target STM32L496ZG_NUCLEO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO_144
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L4xx_Nucleo_144;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio.c
  group Drivers/BSP/STM32L4xx_Nucleo_144
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo_144/: stm32l4xx_nucleo_144.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_cortex.c stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_spi.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Doc
    ../: readme.txt
  group Demo/MDK-ARM
    ./: startup_stm32l496xx.s
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Demo/User
    ../Src/: main.c fatfs_storage.c stm32l4xx_it.c
software components: CMSIS:CORE 4.3.0
