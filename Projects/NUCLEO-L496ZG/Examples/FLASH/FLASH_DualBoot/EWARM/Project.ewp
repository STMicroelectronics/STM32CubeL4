# IAR project Project.ewp, settings and files
configuration FLASH_DualBoot_Bank1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496ZG ST STM32L496ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L496xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO_144; FLASH_BANK1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo_144
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FLASH_DualBoot.bin
  ILINK.IlinkOutputFile: FLASH_DualBoot.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_DualBoot_Bank2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L496xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO_144; FLASH_BANK2
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo_144/: stm32l4xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c
  group Example/EWARM
    ./: startup_stm32l496xx.s
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
