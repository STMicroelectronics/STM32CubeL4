# IAR project Project.ewp, settings and files
configuration STM32L4A6ZG_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4A6ZG ST STM32L4A6ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4A6xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO_144
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo_144
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L49ZG-Nucleo_144.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l4a6xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: Expected_Results.txt readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo_144/: stm32l4xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32l4a6xx.s
  group Example/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
