# IAR project Project.ewp, settings and files
configuration STM32L496ZG_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496ZG ST STM32L496ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L496xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO_144
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo_144
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L49ZG-Nucleo_144.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Example/EWARM
    ./: startup_stm32l496xx.s
  group Drivers/BSP/STM32L4xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo_144/: stm32l4xx_nucleo_144.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_dac.c stm32l4xx_hal_opamp.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
