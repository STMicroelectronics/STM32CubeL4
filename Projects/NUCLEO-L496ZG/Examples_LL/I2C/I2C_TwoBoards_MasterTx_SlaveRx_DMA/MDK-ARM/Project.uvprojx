# Keil uVision project Project.uvprojx, settings and files
target STM32L496ZG_NUCLEO (ARM-ADS)
  device: STM32L496ZGTx STMicroelectronics
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L496ZG_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L496xx,USE_STM32L4XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc
  library: MicroLIB
  group Example/MDK-ARM
    ./: startup_stm32l496xx.s
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/User
    ../Src/: stm32l4xx_it.c main.c
  group Drivers/STM32L4xx_LL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c
software components: CMSIS:CORE 4.3.0
