# Keil uVision project Project.uvprojx, settings and files
target STemWin-STM32L4R9I-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: IROM_DL(0x08000000-0x8005FFF) IROM_ML(0x08006000-0x8042FFF) IROM_ML2(0x08043000-0x807FFFF) IROM_STEW(0x08080000-0x80FFFFF) IROM_TGFX(0x08100000-0x817FFFF) IROM_EWIZ(0x08180000-0x81FFFFF) IRAM(0x20000000-0x2009FFFF) IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IRAM3(0x20040000-0x2009FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STemWin-STM32L4R9I-Discovery_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BSP_USE_CMSIS_OS,GUI_KEEP=__root,VECT_TAB_OFFSET=0x00,USE_HAL_DRIVER,STM32L4R9xx,USE_STM32L4R9I_DISCOVERY,USE_IOEXPANDER,USE_GVO_390x390,BSP_LCD_COLOR_DEPTH_16_BPP,WA_RESET_AFTER_IDD_MEASURE
  c misc: --wchar32
  c include: ../Config;../Core/Inc;../Gui/Target;../Gui/Core/generated;../Modules/common;../Modules/audioplayer;../Modules/audiorecorder;../Modules/iddmeasure;../../../../../Utilities/CPU;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L4R9I-Discovery;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STemWin/inc;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STemWin-STM32L4R9I-Discovery\Exe\STemWin-STM32L4R9I-Discovery_V1.0.sct
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Application/User/Core
    ../Core/Src/: dimming.c k_bsp.c k_menu.c k_mfx.c k_module.c k_rtc.c k_storage.c main.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c ts.c
  group Application/User/Gui/audio_player
    ../Gui/Core/audio_player/: audio_player_win.c
  group Application/User/Gui/audio_player/generated
    ../Gui/Core/audio_player/generated/: player_background.c player_icon.c player_icon_equalizer_pressed.c player_icon_equalizer_unpressed.c player_icon_minus_pressed.c player_icon_minus_unpressed.c player_icon_next_pressed.c player_icon_next_unpressed.c player_icon_pause_pressed.c player_icon_pause_unpressed.c player_icon_play_pressed.c player_icon_play_unpressed.c player_icon_plus_pressed.c player_icon_plus_unpressed.c player_icon_previous_pressed.c player_icon_previous_unpressed.c player_icon_repeat_all_pressed.c player_icon_repeat_all_unpressed.c player_icon_repeat_one_pressed.c player_icon_repeat_one_unpressed.c player_icon_sound_mute.c player_icon_speaker_transparent.c player_icon_speaker_white.c
  group Application/User/Gui/audio_player/generated/eq
    ../Gui/Core/audio_player/generated/eq/: player_eq_button_equalizer.c player_eq_progress_bar_cercle.c player_eq_progress_bar_niddle.c player_eq_separation.c player_eq_shape.c
  group Application/User/Gui/audio_player/generated/progress_bar
    ../Gui/Core/audio_player/generated/progress_bar/: player_pb_playback_full.c player_pb_playback_niddle.c player_pb_volume_bkg.c player_pb_volume_empty.c player_pb_volume_full.c
  group Application/User/Gui/audio_recorder
    ../Gui/Core/audio_recorder/: audio_recorder_win.c
  group Application/User/Gui/audio_recorder/generated
    ../Gui/Core/audio_recorder/generated/: animation_graph.c cancel_button_selected.c cancel_button_unselected.c menu_button.c menu_list.c micro_icon.c pause_button_selected.c pause_button_unselected.c record_button_unselected.c record_info.c record_time_shape.c recording_cercle1.c recording_cercle2.c recording_cercle3.c recording_cercle4.c save_button_selected.c save_button_unselected.c
  group Application/User/Gui/clock_faces
    ../Gui/Core/clock_faces/: clock_faces_win.c
  group Application/User/Gui/clock_faces/generated
    ../Gui/Core/clock_faces/generated/alarm/animation_alarme/ligne1/: alarm_animation1_10.c alarm_animation1_100.c alarm_animation1_20.c alarm_animation1_30.c alarm_animation1_40.c alarm_animation1_50.c alarm_animation1_60.c alarm_animation1_70.c alarm_animation1_80.c alarm_animation1_90.c
    ../Gui/Core/clock_faces/generated/alarm/animation_alarme/ligne2/: alarm_animation2_10.c alarm_animation2_100.c alarm_animation2_20.c alarm_animation2_30.c alarm_animation2_40.c alarm_animation2_50.c alarm_animation2_60.c alarm_animation2_70.c alarm_animation2_80.c alarm_animation2_90.c
    ../Gui/Core/clock_faces/generated/alarm/animation_alarme/ligne3/: alarm_animation3_10.c alarm_animation3_100.c alarm_animation3_20.c alarm_animation3_30.c alarm_animation3_40.c alarm_animation3_50.c alarm_animation3_60.c alarm_animation3_70.c alarm_animation3_80.c alarm_animation3_90.c
    ../Gui/Core/clock_faces/generated/set_alarm/: AlarmList.c bkc_setalarm.c fr_text.c mo_text.c sa_text.c set_alarm_locked.c set_alarm_unlocked.c su_text.c th_text.c tu_text.c we_text.c
    ../Gui/Core/clock_faces/generated/analog_clock_1/backgrounds/: analog_clock1.c analog_clock1_background.c
    ../Gui/Core/clock_faces/generated/analog_clock_1/ticks/: analog_clock1_cercle.c
    ../Gui/Core/clock_faces/generated/analog_clock_2/backgrounds/: analog_clock2_background.c
    ../Gui/Core/clock_faces/generated/analog_clock_2/ticks/: analog_clock2_cercle.c
    ../Gui/Core/clock_faces/generated/swipe_up_settings/: clock1_small.c clock2_small.c clock3_small.c clock4_small.c swipe_up_arrow.c swipe_up_arrow_up.c swipe_up_settings_background.c
    ../Gui/Core/clock_faces/generated/set_time_date/date/unselected/: clock_blue_cercle_date.c screen_clock_ic_date.c
    ../Gui/Core/clock_faces/generated/set_time_date/date/selected/: clock_white_cercle_date.c
    ../Gui/Core/clock_faces/generated/digital_clock_1/backgrounds/: digital_clock1_background.c digital_clock1_background_day.c
    ../Gui/Core/clock_faces/generated/digital_clock_2/backgrounds/: digital_clock2_background.c
    ../Gui/Core/clock_faces/generated/digital_clock_2/cercle_hover/: digital_clock2_cercle_1.c digital_clock2_cercle_2.c
    ../Gui/Core/clock_faces/generated/alarm/: ic_alarm_repeat_alarm.c small_blue_bell.c small_white_bell.c
    ../Gui/Core/clock_faces/generated/settings/selected/: ic_settings_selected.c settings_blue_cercle_selected.c settings_white_cercle_selected.c
    ../Gui/Core/clock_faces/generated/settings/unselected/: ic_settings_unselected.c
    ../Gui/Core/clock_faces/generated/set_alarm/alarm/: new_alarm_icon.c new_alarm_icon_cercle.c new_alarm_icon_selected.c
    ../Gui/Core/clock_faces/generated/repeat/: repeat_cercle_date.c repeat_selected.c repeat_unselected.c
    ../Gui/Core/clock_faces/generated/set_time_date/time/selected/: screen_clock_time.c
    ../Gui/Core/clock_faces/generated/set_alarm/new_alarm/: set_alarm_cercle_new_alarm.c set_alarm_cercle_new_alarm_disabled.c set_alarm_ic_new_alarm.c set_alarm_ic_remove_alarm.c
    ../Gui/Core/clock_faces/generated/set_date/: set_time_shape.c
    ../Gui/Core/clock_faces/generated/set_alarm/shape/: shape_alarms.c
  group Application/User/Gui/generated/bitmaps
    ../Gui/Core/generated/bitmaps/: back_button_bkg.c background.c button_back.c module_entry_icon.c reflection_cover.c
  group Application/User/Gui/generated/fonts
    ../Gui/Core/generated/fonts/: font25.c Roboto_C_regular100.c Roboto_C_Regular35.c Roboto_Light100.c Roboto_Light31.c RobotoC_bold22.c RobotoC_regular22.c RobotoCn_bold27.c RobotoCnBold48.c RobotoCondensed_light25.c RobotoRegular50.c
  group Application/User/Gui/information
    ../Gui/Core/information/: information_win.c
  group Application/User/Gui/information/generated
    ../Gui/Core/information/generated/: info_icon.c information.c
  group Application/User/Gui/power_measurement
    ../Gui/Core/power_measurement/: power_measurement_win.c
  group Application/User/Gui/power_measurement/generated
    ../Gui/Core/power_measurement/generated/buttons/button_run/animation/cercle1/: animation_circle1_opacity10.c animation_circle1_opacity100.c animation_circle1_opacity20.c animation_circle1_opacity30.c animation_circle1_opacity40.c animation_circle1_opacity50.c animation_circle1_opacity60.c animation_circle1_opacity70.c animation_circle1_opacity80.c animation_circle1_opacity90.c
    ../Gui/Core/power_measurement/generated/buttons/button_run/animation/cercle2/: animation_circle2_opacity10.c animation_circle2_opacity100.c animation_circle2_opacity20.c animation_circle2_opacity30.c animation_circle2_opacity40.c animation_circle2_opacity50.c animation_circle2_opacity60.c animation_circle2_opacity70.c animation_circle2_opacity80.c animation_circle2_opacity90.c
    ../Gui/Core/power_measurement/generated/slide/: arrow_left.c arrow_left_gray.c arrow_left_shape.c arrow_left_shape_gray.c arrow_right.c arrow_right_gray.c arrow_right_shape.c arrow_right_shape_gray.c
    ../Gui/Core/power_measurement/generated/buttons/button_run/: button_run_cercle.c button_run_selected.c button_run_unselected.c
    ../Gui/Core/power_measurement/generated/modes/low_power_mode/: low_power_mode.c low_power_run_mode_text.c
    ../Gui/Core/power_measurement/generated/modes/low_power_sleep_mode/: low_power_sleep_mode.c low_power_sleep_mode_text.c
    ../Gui/Core/power_measurement/generated/background/: power_icon.c power_measurement_background.c
    ../Gui/Core/power_measurement/generated/modes/run_mode/: run_mode.c run_mode_text.c
    ../Gui/Core/power_measurement/generated/shapes/: shape_blue.c shape_measurement.c shape_white_line.c
    ../Gui/Core/power_measurement/generated/modes/shutdown/: shutdown.c shutdown_mode_rtc_text.c shutdown_mode_text.c
    ../Gui/Core/power_measurement/generated/modes/sleep_mode/: sleep_mode.c sleep_mode_text.c
    ../Gui/Core/power_measurement/generated/modes/standby/: standby_mode.c standby_mode_rtc_text.c standby_mode_text.c
    ../Gui/Core/power_measurement/generated/modes/stop_mode/: stop_2_mode_text.c stop_mode.c
  group Application/User/Gui/reset
    ../Gui/Core/reset/: reset_win.c
  group Application/User/Gui/reset/generated
    ../Gui/Core/reset/generated/: reset_button.c reset_icon.c
  group Application/User/Modules/audio_player
    ../Modules/audioplayer/: audio_player_app.c
  group Application/User/Modules/audio_recorder
    ../Modules/audiorecorder/: audio_recorder_app.c
  group Application/User/Modules/common
    ../Modules/common/: audio_if.c
  group Application/User/Modules/iddmeasure
    ../Modules/iddmeasure/: iddmeasure.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../../MenuLauncher/: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c
    ../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L4R9I-Discovery
    ../../../../../Drivers/BSP/STM32L4R9I-Discovery/: stm32l4r9i_discovery.c stm32l4r9i_discovery_audio.c stm32l4r9i_discovery_idd.c stm32l4r9i_discovery_io.c stm32l4r9i_discovery_ospi_nor.c stm32l4r9i_discovery_sd.c stm32l4r9i_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Drivers
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Core/Src/: sd_diskio_dma.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM4_OS_wc32_ot_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
target STemWin-STM32L4R9I-Discovery_OoB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: as above
  output: STemWin-STM32L4R9I-Discovery_OoB_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BSP_USE_CMSIS_OS,WA_RESET_AFTER_IDD_MEASURE,GUI_KEEP=__root,VECT_TAB_OFFSET=0x80000,USE_HAL_DRIVER,STM32L4R9xx,USE_STM32L4R9I_DISCOVERY,USE_IOEXPANDER,USE_GVO_390x390,BSP_LCD_COLOR_DEPTH_16_BPP
  c misc: --wchar32
  c include: as above
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: STemWin-STM32L4R9I-Discovery_OoB\Exe\STemWin-STM32L4R9I-Discovery_OoB_V1.0.sct
  group added to the first target's files
    ../: readme.txt
  group left out of the first target's files
    ../../MenuLauncher/: readme.txt
software components: CMSIS:CORE 4.3.0
