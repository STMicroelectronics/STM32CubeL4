<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Project</project>
        <configuration>STemWin-STM32L4R9I-Discovery</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>STemWin-STM32L4R9I-Discovery_OoB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


