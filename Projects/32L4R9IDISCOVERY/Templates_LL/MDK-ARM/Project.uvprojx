# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_FULL_LL_DRIVER,HSE_VALUE=16000000
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/User
    ../Src/: stm32l4xx_it.c main.c
  group Drivers/STM32L4xx_LL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_crc.c stm32l4xx_ll_adc.c stm32l4xx_ll_opamp.c stm32l4xx_ll_exti.c stm32l4xx_ll_rtc.c stm32l4xx_ll_lptim.c stm32l4xx_ll_gpio.c stm32l4xx_ll_rcc.c stm32l4xx_ll_dac.c stm32l4xx_ll_spi.c stm32l4xx_ll_pwr.c stm32l4xx_ll_usart.c stm32l4xx_ll_crs.c stm32l4xx_ll_dma.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_comp.c stm32l4xx_ll_tim.c stm32l4xx_ll_utils.c stm32l4xx_ll_rng.c
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
software components: CMSIS:CORE 4.3.0
