# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IRAM3(0x20040000-0x2009FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L4R9I-Discovery;../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4R9I-Discovery
    ../../../../Drivers/BSP/STM32L4R9I-Discovery/: stm32l4r9i_discovery_ospi_nor.c stm32l4r9i_discovery_ts.c stm32l4r9i_discovery_audio.c stm32l4r9i_discovery.c stm32l4r9i_discovery_idd.c stm32l4r9i_discovery_lcd.c stm32l4r9i_discovery_io.c stm32l4r9i_discovery_sd.c stm32l4r9i_discovery_camera.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal.c stm32l4xx_ll_usb.c stm32l4xx_hal_sd.c stm32l4xx_hal_tsc.c stm32l4xx_hal_firewall.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_uart.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_dac.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_rcc.c stm32l4xx_hal_cryp.c stm32l4xx_hal_nor.c stm32l4xx_hal_adc.c stm32l4xx_hal_iwdg.c stm32l4xx_ll_fmc.c stm32l4xx_hal_rng.c stm32l4xx_hal_hcd.c stm32l4xx_hal_opamp.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_gpio.c stm32l4xx_hal_lptim.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_sram.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_pcd.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_hash.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_usart.c stm32l4xx_hal_dsi.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_nand.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_sai.c stm32l4xx_hal_crc.c stm32l4xx_hal_tim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_smbus.c stm32l4xx_hal_sai_ex.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ov9655/: ov9655.c
    ../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c
    ../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
software components: CMSIS:CORE 4.3.0
