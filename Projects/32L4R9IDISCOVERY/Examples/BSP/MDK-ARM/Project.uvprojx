# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I-Discovery (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2009FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L4R9I-Discovery
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,LCD_DIMMING,LCD_OFF_AFTER_DIMMING
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32L4R9I-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4R9I-Discovery
    ../../../../../Drivers/BSP/STM32L4R9I-Discovery/: stm32l4r9i_discovery_idd.c stm32l4r9i_discovery_lcd.c stm32l4r9i_discovery_sd.c stm32l4r9i_discovery_ospi_nor.c stm32l4r9i_discovery.c stm32l4r9i_discovery_io.c stm32l4r9i_discovery_ts.c stm32l4r9i_discovery_camera.c stm32l4r9i_discovery_psram.c stm32l4r9i_discovery_audio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_nor.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_uart.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sd.c stm32l4xx_hal_pwr.c stm32l4xx_hal_ospi.c stm32l4xx_hal_sram.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_flash.c stm32l4xx_hal_gpio.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../../Drivers/BSP/Components/ov9655/: ov9655.c
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c
  group Example/User
    ../Src/: audio_record.c touchscreen.c ospi_nor.c main.c joystick.c lcd.c psram.c idd.c led.c stm32l4xx_it.c audio_play.c sd.c
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
software components: CMSIS:CORE 4.3.0
