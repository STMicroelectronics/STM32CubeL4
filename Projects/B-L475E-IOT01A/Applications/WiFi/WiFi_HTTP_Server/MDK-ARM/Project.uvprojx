# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx,USE_STM32L475_DISCOVERY
  c misc: --C99
  c include: ../Inc;../../Common/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_tsensor.c
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_uart.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr_ex.c
  group Application/User
    ../Src/: stm32l4xx_it.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/WIFI
    ../../Common/Src/: es_wifi.c wifi.c es_wifi_io.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
software components: CMSIS:CORE 4.3.0
