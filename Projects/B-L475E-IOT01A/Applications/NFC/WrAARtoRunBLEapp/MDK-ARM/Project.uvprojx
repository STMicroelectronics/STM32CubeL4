# Keil uVision project Project.uvprojx, settings and files
target NFC_AARtoRunBLEapp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: NFC_AARtoRunBLEapp
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475_IOT_DISCO
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components/m24sr;../../Common/M24SR;../../Common/NDEF_TagType4_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/STM32L4xx_HAL_Drivers
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal.c stm32l4xx_hal_pwr.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: stm32l4xx_it.c main.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/m24sr/: m24sr.c
  group Application/Common/NDEF_TagType4_lib
    ../../Common/NDEF_TagType4_lib/: lib_NDEF_Email.c lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_URI.c lib_NDEF_SMS.c lib_NDEF_Geo.c lib_TT4_interface.c lib_NDEF_Vcard.c lib_NDEF_MyApp.c
  group Application/Common/M24SR_wrappers
    ../../Common/M24SR/: m24sr_wrapper.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L475x_IoT_Discovery
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
software components: CMSIS:CORE 4.3.0
