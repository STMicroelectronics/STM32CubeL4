# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01-P2P (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01-P2P
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,NO_EEPROM,P2P_DEMO,SPIRIT1_ST_SHIELD,USE_STM32L475_IOT_DISCO
  c misc: --C99
  c include: ../Inc;../../Common;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/User
    ../Src/: p2p_app.c stm32l4xx_it.c clocks_and_power.c main.c
  group Drivers/BSP/STM32L475_IoT-Discovery
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal.c stm32l4xx_hal_pcd.c stm32l4xx_hal_spi.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_uart.c stm32l4xx_hal_cortex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_lptim.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rtc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_rcc.c
  group Application/Common(spsgrfdrv)
    ../../Common/: spsgrf_app.c spsgrf.c spsgrf_io.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
software components: CMSIS:CORE 4.3.0
