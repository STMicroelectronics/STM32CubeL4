# Keil uVision project Project.uvprojx, settings and files
target B-L475E-IOT01_USBD-FS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E-IOT01_USBD-FS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx,MQTTCLIENT_PLATFORM_HEADER=MQTTCMSIS.h,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,SENSOR,RFU
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Application/User
    ../Src/: usbd_conf.c stm32l4xx_it.c usbd_desc.c main.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_usb.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c
  group Middlewares/STM32_USBD_Library/Class/HID
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
