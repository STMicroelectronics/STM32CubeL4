# Keil uVision project Project.uvprojx, settings and files
target B-L475E_IOT01 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: B-L475E_IOT01
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx,USE_STM32L475E_IOT01
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-L475E-IOT01;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c timers.c list.c event_groups.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_flash.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_lptim.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart_ex.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c
  group Applications/User
    ../Src/: main.c low_power_tick_management_LPTIM.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_timebase_lptim.c
  group Applications/MDK-ARM
    ./: startup_stm32l475xx.s
  group Middlewares/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
