# IAR project Project.ewp, settings and files
configuration STM32L412KB_NUCLEO_Gravitech_4digits (ARM, debug)
  General.OGChipSelectEditMenu: STM32L412KB ST STM32L412KB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L412xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo_32
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l412xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo_32
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo_32/: stm32l4xx_nucleo_32.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
  group Example/EWARM
    ./: startup_stm32l412xx.s
