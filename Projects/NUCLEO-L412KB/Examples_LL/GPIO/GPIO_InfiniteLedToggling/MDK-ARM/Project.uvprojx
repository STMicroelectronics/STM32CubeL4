# Keil uVision project Project.uvprojx, settings and files
target STM32L412KB_NUCLEO_GPIO_InfiniteLedToggling (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L412KBTx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20007FFF) IRAM2(0x10000000-0x10001FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L412xx
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo_32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l412xx.s
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_LL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_gpio.c stm32l4xx_ll_utils.c
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
software components: CMSIS:CORE 4.3.0
