# Keil uVision project Project.uvprojx, settings and files
target STM32L412RB_NUCLEO_GPIO_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L412RBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.1.0
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20009FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L412RB_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L412xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO_64_SMPS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Example/User
    ../Src/: stm32l4xx_it.c main.c
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Doc
    ../: readme.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal.c stm32l4xx_hal_gpio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/MDK-ARM
    ./: startup_stm32l412xx.s
software components: CMSIS:CORE 4.3.0
