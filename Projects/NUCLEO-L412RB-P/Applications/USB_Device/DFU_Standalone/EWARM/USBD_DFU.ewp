# IAR project USBD_DFU.ewp, settings and files
configuration STM32L412RB_NUCLEO_USBD_DFU-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32L412RB ST STM32L412RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L412xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO_64_SMPS
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\DFU\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_DFU.bin
  ILINK.IlinkOutputFile: STM32L412_USBD_DFU-FS.out
  ILINK.IlinkIcfFile: stm32l412xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l412xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c usbd_conf.c usbd_desc.c usbd_dfu_flash.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart.c stm32l4xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
