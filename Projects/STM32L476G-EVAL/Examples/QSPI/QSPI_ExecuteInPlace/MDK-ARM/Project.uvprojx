# Keil uVision project Project.uvprojx, settings and files
target STM32L476G_EVAL (ARM-ADS)
  device: STM32L476ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: STM32L476G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L476G_EVAL_REVB,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L476G_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: STM32L476G_EVAL\STM32L476G_EVAL.sct
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Drivers/BSP/STM32L476G_EVAL
    ../../../../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval.c stm32l476g_eval_io.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal.c stm32l4xx_hal_uart.c stm32l4xx_hal_usart.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
