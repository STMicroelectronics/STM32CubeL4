# Keil uVision project Project.uvprojx, settings and files
target STM32L476G_EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L486ZG STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.2
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L486xx,USE_HAL_DRIVER,__DBG_ITM
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\STM32L476G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Doc
    ../: Expected_Results.txt readme.txt
  group Example/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
    ./: Retarget.c Serial.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal.c
  group Example/MDK-ARM
    ./: startup_stm32l486xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval.c
