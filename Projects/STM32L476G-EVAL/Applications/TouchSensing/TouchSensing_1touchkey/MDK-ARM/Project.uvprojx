# Keil uVision project Project.uvprojx, settings and files
target STM32L476G_EVAL (ARM-ADS)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476G_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L476G_EVAL_REVB,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L476G_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Utilities\Log;..\..\..\..\..\..\Utilities\CPU;..\..\..\..\..\..\Middlewares\ST\STM32_TouchSensing_Library\inc;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l4xx_hal_msp.c stmCriticalSection.c tsl_user.c stm32l4xx_it.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Drivers/BSP/STM32L476G_EVAL
    ../../../../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval.c stm32l476g_eval_io.c stm32l476g_eval_lcd.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_sram.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal.c stm32l4xx_hal_tsc.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_ll_fmc.c stm32l4xx_hal_uart.c
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl.c tsl_ecs.c tsl_acq_tsc.c tsl_globals.c tsl_acq.c tsl_linrot.c tsl_time.c tsl_object.c tsl_touchkey.c tsl_filter.c tsl_dxs.c
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
