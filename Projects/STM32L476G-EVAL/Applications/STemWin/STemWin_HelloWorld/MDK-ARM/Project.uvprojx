# Keil uVision project Project.uvprojx, settings and files
target STM32L476G_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476ZGTx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L476G_EVAL_REVB,USE_IOEXPANDER
  c misc: --wchar32
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L476G_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STemWin/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: BASIC_HelloWorld.c main.c stm32l4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hx8347g/: hx8347g.c
    ../../../../../../Drivers/BSP/Components/hx8347i/: hx8347i.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM32L476G_EVAL
    ../../../../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval.c stm32l476g_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_sram.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_fmc.c
  group Middlewares/STemWin/Config
    ../Src/: GUIConf_stm32l476g_eval.c LCDConf_stm32l476g_eval.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM4_wc32.a
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
software components: CMSIS:CORE 4.3.0
