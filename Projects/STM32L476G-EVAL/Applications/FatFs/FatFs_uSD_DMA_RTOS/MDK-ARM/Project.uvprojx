# Keil uVision project Project.uvprojx, settings and files
target STM32L476G_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L476G_EVAL_REVB,USE_IOEXPANDER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L476G_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FatFs/Drivers
    ../Src/: sd_diskio_dma_rtos.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/BSP/STM32L476G_EVAL
    ../../../../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval_sd.c stm32l476g_eval.c stm32l476g_eval_io.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_i2c.c stm32l4xx_hal_tim.c stm32l4xx_hal.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_rcc_ex.c
  group Application/User
    ../Src/: stm32l4xx_hal_timebase_tim.c main.c stm32l4xx_it.c
software components: CMSIS:CORE 4.3.0
