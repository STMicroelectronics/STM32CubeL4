# Keil uVision project Project.uvprojx, settings and files
target STM32L476G_EVAL_USBD-FS (ARM-ADS)
  device: STM32L476ZG STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: STM32L476G_EVAL_USBD-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L476G_EVAL_REVB,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32L476G_EVAL;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc_bot.c usbd_msc.c usbd_msc_data.c usbd_msc_scsi.c
  group Drivers/BSP/STM32L476G_EVAL
    ../../../../../../Drivers/BSP/STM32L476G_EVAL/: stm32l476g_eval_sd.c stm32l476g_eval_io.c stm32l476g_eval.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_sd.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_pwr_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_flash.c stm32l4xx_hal_dma.c stm32l4xx_hal_uart.c stm32l4xx_hal_sram.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_cortex.c stm32l4xx_hal.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_spi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c
  group Application/User
    ../Src/: usbd_storage.c usbd_conf.c usbd_desc.c main.c stm32l4xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/stmpe1600/: stmpe1600.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Doc
    ../: readme.txt
