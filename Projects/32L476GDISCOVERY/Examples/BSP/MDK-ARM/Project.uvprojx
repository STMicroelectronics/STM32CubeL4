# Keil uVision project Project.uvprojx, settings and files
target STM32L476G-Discovery (ARM-ADS)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32L476G-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L476G_DISCO_REVB
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\STM32L476G-Discovery;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_i2c.c stm32l4xx_hal_dma.c stm32l4xx_hal_spi.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_qspi.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_lcd.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_sai.c stm32l4xx_hal.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L476G-Discovery
    ../../../../../Drivers/BSP/STM32L476G-Discovery/: stm32l476g_discovery_audio.c stm32l476g_discovery_idd.c stm32l476g_discovery_glass_lcd.c stm32l476g_discovery.c stm32l476g_discovery_qspi.c stm32l476g_discovery_gyroscope.c
  group Drivers/CMSIS
    ./: startup_stm32l476xx.s
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/lsm303c/: lsm303c.c
    ../../../../../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
  group User
    ../Src/: lcdglass.c audio_record.c idd.c qspi.c joystick.c gyro.c led.c stm32l4xx_it.c audio_play.c main.c
software components: CMSIS:CORE 4.1.0
