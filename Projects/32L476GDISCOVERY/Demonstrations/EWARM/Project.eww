<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Project</project>
        <configuration>STM32L476G-Discovery</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


