# Keil uVision project Project.uvprojx, settings and files
target STM32L433RC_NUCLEO (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L433RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L433RC_NUCLEO +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L433xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L4xx_Nucleo;../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Drivers/BSP/STM32L433RC_NUCLEO
    ../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc_ex.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_dac.c stm32l4xx_ll_fmc.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_usart.c stm32l4xx_hal_nand.c stm32l4xx_hal_smbus.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_nor.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_cryp.c stm32l4xx_hal_firewall.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_dma.c stm32l4xx_hal_lcd.c stm32l4xx_hal_flash.c stm32l4xx_hal_sram.c stm32l4xx_hal_tsc.c stm32l4xx_hal_hcd.c stm32l4xx_hal_tim.c stm32l4xx_ll_usb.c stm32l4xx_hal_pcd.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_sd.c stm32l4xx_hal_comp.c stm32l4xx_hal_smartcard.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_opamp.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_crc.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal.c stm32l4xx_hal_rng.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_can.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_i2c.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_rcc_ex.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32l433xx.s
software components: CMSIS:CORE 4.3.0
