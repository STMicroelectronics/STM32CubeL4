# Keil uVision project Project.uvprojx, settings and files
target STM32L4P5ZG_NUCLEO_144_PKA_ModularExponentiation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4Q5ZGTx STMicroelectronics
  pack: Keil.STM32L4P5xx_DFP.1.0.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L4Q5xx,USE_STM32L4XX_NUCLEO_144
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Doc
    ../Src/: ciphertext.bin plaintext.bin rsa_priv_2048.pem rsa_pub_2048.pem
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_LL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32l4q5xx.s
  group Example/User
    ../Src/: ciphertext.c main.c plaintext.c rsa_priv_2048.c rsa_pub_2048.c stm32l4xx_it.c
software components: CMSIS:CORE 4.3.0
