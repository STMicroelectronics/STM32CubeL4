# Keil uVision project Project.uvprojx, settings and files
target STM32L4P5ZG_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4P5ZGTx STMicroelectronics
  pack: Keil.STM32L4P5xx_DFP.1.0.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2004FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L4P5xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_LL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pka.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32l4p5xx.s
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
software components: CMSIS:CORE 4.3.0
