# Keil uVision project Project.uvprojx, settings and files
target STM32L4R5ZI_NUCLEO (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R5ZITx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R5xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO_144
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo_144;../../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Example/User/TestConso
    ../Src/: standby_test.c run_range2_test.c lprun_test.c sleep_range1_test .c shutdown_test.c sleep_range2_test.c standby_rtc_sram2_test.c standby_rtc_test.c stop1_mroff_test.c lpsleep_test.c stop1_mroff_rtc_test.c run_range1_test.c stop2_rtc_test.c stop2_test.c
  group Example/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Example/MDK-ARM
    ./: startup_stm32l4r5xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_rcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo_144/: stm32l4xx_nucleo_144.c
software components: CMSIS:CORE 4.3.0
