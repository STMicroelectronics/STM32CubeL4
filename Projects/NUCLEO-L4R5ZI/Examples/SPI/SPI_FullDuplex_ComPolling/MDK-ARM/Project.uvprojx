# Keil uVision project Project.uvprojx, settings and files
target STM32L4R5ZI_NUCLEO (ARM-ADS)
  device: STM32L4R5ZITx STMicroelectronics
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L4R5xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo_144
  library: MicroLIB
  group Example/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32l4r5xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo_144/: stm32l4xx_nucleo_144.c
software components: CMSIS:CORE 4.3.0
