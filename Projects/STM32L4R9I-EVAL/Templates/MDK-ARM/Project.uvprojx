# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,USE_GVO_390x390,USE_ROCKTECH_480x272_NOT_SET
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32L4R9I_EVAL;../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval_sram.c stm32l4r9i_eval_dsi_lcd.c stm32l4r9i_eval_rgb_lcd.c stm32l4r9i_eval_ospi_nor.c stm32l4r9i_eval.c stm32l4r9i_eval_rgb_ts.c stm32l4r9i_eval_idd.c stm32l4r9i_eval_eeprom.c stm32l4r9i_eval_io.c stm32l4r9i_eval_nor.c stm32l4r9i_eval_audio.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_sai_ex.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_lptim.c stm32l4xx_hal_mmc.c stm32l4xx_hal_mmc_ex.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_flash.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_can.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_uart.c stm32l4xx_hal_firewall.c stm32l4xx_hal_hcd.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_rcc.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_nor.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal.c stm32l4xx_hal_irda.c stm32l4xx_hal_cryp.c stm32l4xx_hal_comp.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_fmc.c stm32l4xx_hal_hash.c stm32l4xx_hal_ospi.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_smbus.c stm32l4xx_hal_opamp.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pwr.c stm32l4xx_hal_spi.c stm32l4xx_hal_adc.c stm32l4xx_hal_dma.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_nand.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/User
    ../Src/: stm32l4xx_it.c main.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
