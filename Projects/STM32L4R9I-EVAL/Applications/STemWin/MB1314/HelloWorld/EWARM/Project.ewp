# IAR project Project.ewp, settings and files
configuration STM32L4R9I-EVAL-MB1314 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4R9xx; USE_STM32L4R9I_EVAL; USE_IOEXPANDER; USE_GVO_390x390; BSP_LCD_COLOR_DEPTH_16_BPP
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\STemWin\Target; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32L4R9I_EVAL; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\Components\ft3x67; ..\..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152; ..\..\..\..\..\..\..\Middlewares\ST\STemWin\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L4R9I-EVAL-MB1314_1.0.0.hex
  ILINK.IlinkOutputFile: STM32L4R9I-EVAL-MB1314.out
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l4r9xx.s
  group Application/User/App
    ../STemWin/App/: BASIC_HelloWorld.c
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval.c stm32l4r9i_eval_io.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_fmc.c stm32l4xx_ll_sdmmc.c
  group Middlewares/STemWin/Library
    ../../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM4_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Target
    ../STemWin/Target/: GUIConf.c LCDConf.c
