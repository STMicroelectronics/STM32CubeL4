# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I-EVAL-MB1314 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2009FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L4R9I-EVAL-MB1314 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L4R9xx,USE_STM32L4R9I_EVAL,USE_IOEXPANDER,USE_GVO_390x390,BSP_LCD_COLOR_DEPTH_16_BPP
  c misc: --wchar32
  c include: ../Core/Inc;../STemWin/Target;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32L4R9I_EVAL;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Drivers/BSP/Components/ft3x67;../../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../../Middlewares/ST/STemWin/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  scatter file: STM32L4R9I-EVAL-MB1314\Exe\STM32L4R9I-EVAL-MB1314.sct
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Application/User/App
    ../STemWin/App/: BASIC_HelloWorld.c
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval.c stm32l4r9i_eval_io.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_fmc.c stm32l4xx_ll_sdmmc.c
  group Middlewares/STemWin/Library
    ../../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM4_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/STemWin/Target
    ../STemWin/Target/: GUIConf.c LCDConf.c
software components: CMSIS:CORE 4.3.0
