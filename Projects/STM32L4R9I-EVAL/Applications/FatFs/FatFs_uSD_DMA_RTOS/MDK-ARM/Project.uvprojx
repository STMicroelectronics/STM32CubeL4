# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,USE_GVO_390x390
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4R9I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval.c stm32l4r9i_eval_io.c stm32l4r9i_eval_sd.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_sdmmc.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: main.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c sd_diskio_dma_rtos.c
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
