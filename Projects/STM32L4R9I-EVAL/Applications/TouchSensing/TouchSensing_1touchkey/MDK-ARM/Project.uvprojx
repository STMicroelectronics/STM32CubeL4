# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,USE_STM32L4R9I_EVAL,USE_GVO_390x390,USE_ROCKTECH_480x272_NOT_SET
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4R9I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_TouchSensing_Library/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval_dsi_ts.c stm32l4r9i_eval.c stm32l4r9i_eval_io.c stm32l4r9i_eval_dsi_lcd.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tsc.c stm32l4xx_hal_dsi.c stm32l4xx_hal_gpio.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_i2c.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_pwr_ex.c
  group Middlewares/STM32_TouchSensing_Library
    ../../../../../../Middlewares/ST/STM32_TouchSensing_Library/src/: tsl_time.c tsl_acq.c tsl_acq_tsc.c tsl_filter.c tsl_globals.c tsl_dxs.c tsl_linrot.c tsl_ecs.c tsl.c tsl_touchkey.c tsl_object.c
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/User
    ../Src/: stmCriticalSection.c stm32l4xx_it.c tsl_user.c main.c stm32l4xx_hal_msp.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
