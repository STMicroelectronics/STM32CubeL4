# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I_EVAL-DSI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L4R9I_EVAL-DSI
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,USE_GVO_390x390,USE_ROCKTECH_480x272_NOT_SET,LCD_DIMMING,LCD_OFF_AFTER_DIMMING
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/BSP/STM32L4R9I_EVAL;../../../../../Utilities/Log;../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dsi.c stm32l4xx_hal_rtc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_sram.c stm32l4xx_hal_i2c.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_tim.c stm32l4xx_hal_nor.c stm32l4xx_hal_cortex.c stm32l4xx_hal_sai.c stm32l4xx_hal_ltdc.c stm32l4xx_ll_fmc.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Example/User
    ../Src/: eeprom.c dsi_lcd.c ospi_nor.c nor.c audio_record.c rgb_lcd.c main.c ospi_ram.c touchscreen.c log.c sd.c joystick.c led.c stm32l4xx_it.c audio_play.c dsi_touchscreen.c sram.c
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval_ospi_ram.c stm32l4r9i_eval_eeprom.c stm32l4r9i_eval_sram.c stm32l4r9i_eval_dsi_ts.c stm32l4r9i_eval.c stm32l4r9i_eval_ospi_nor.c stm32l4r9i_eval_rgb_lcd.c stm32l4r9i_eval_rgb_ts.c stm32l4r9i_eval_sd.c stm32l4r9i_eval_audio.c stm32l4r9i_eval_io.c stm32l4r9i_eval_dsi_lcd.c stm32l4r9i_eval_idd.c stm32l4r9i_eval_nor.c
target STM32L4R9I_EVAL-RGB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4+_DFP.0.0.4
  cpu: as above
  output: STM32L4R9I_EVAL-RGB
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,USE_GVO_390x390_NOT_SET,USE_ROCKTECH_480x272
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
software components: CMSIS:CORE 4.3.0
