# IAR project Project.ewp, settings and files
configuration STM32L4R9I_EVAL-DSI (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; USE_GVO_390x390; USE_ROCKTECH_480x272_NOT_SET; LCD_DIMMING; LCD_OFF_AFTER_DIMMING
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\BSP\STM32L4R9I_EVAL; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L4R9I_EVAL-DSI.hex
  ILINK.IlinkOutputFile: STM32L4R9I_EVAL-DSI.out
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L4R9I_EVAL-RGB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; USE_GVO_390x390_NOT_SET; USE_ROCKTECH_480x272
  OBJCOPY.OOCOutputFile: STM32L4R9I_EVAL-RGB.hex
  ILINK.IlinkOutputFile: STM32L4R9I_EVAL-RGB.out
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval.c stm32l4r9i_eval_audio.c stm32l4r9i_eval_dsi_lcd.c stm32l4r9i_eval_dsi_ts.c stm32l4r9i_eval_eeprom.c stm32l4r9i_eval_idd.c stm32l4r9i_eval_io.c stm32l4r9i_eval_nor.c stm32l4r9i_eval_ospi_nor.c stm32l4r9i_eval_ospi_ram.c stm32l4r9i_eval_rgb_lcd.c stm32l4r9i_eval_rgb_ts.c stm32l4r9i_eval_sd.c stm32l4r9i_eval_sram.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nor.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_fmc.c stm32l4xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32l4r9xx.s
  group Example/User
    ../Src/: audio_play.c audio_record.c dsi_lcd.c dsi_touchscreen.c eeprom.c joystick.c led.c log.c main.c nor.c ospi_nor.c ospi_ram.c rgb_lcd.c sd.c sram.c stm32l4xx_it.c touchscreen.c
  group Utilities
    ../../../../../Utilities/Log/: lcd_log.c
