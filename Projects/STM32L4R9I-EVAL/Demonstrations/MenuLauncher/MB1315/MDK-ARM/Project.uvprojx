# Keil uVision project Project.uvprojx, settings and files
target MenuLauncher-STM32L4R9I-EVAL_MB1315 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: IROM_DL(0x08000000-0x8005FFF) IROM_ML(0x08006000-0x8042FFF) IROM_ML2(0x08043000-0x807FFFF) IROM_STEW(0x08080000-0x80FFFFF) IROM_TGFX(0x08100000-0x817FFFF) IROM_EWIZ(0x08180000-0x81FFFFF) IRAM(0x20000000-0x2009FFFF) IRAM(0x60000000-0x607FFFFF) IRAM(0x70000000-0x701FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: MenuLauncher-STM32L4R9I-EVAL_MB1315_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L4R9xx,USE_STM32L4R9I_EVAL,USE_IOEXPANDER,USE_ROCKTECH_480x272,BSP_USE_CMSIS_OS
  c misc: --wchar32
  c include: ../Config;../Core/Inc;../Gui/Target;../Gui/STemWin_Addons;../Gui/App/generated;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4R9I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/ft5336;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/iss66wvh8m8;../../../../../../Drivers/BSP/Components/mx25lm51245g;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Application/User/Core
    ../Core/Src/: bsp.c k_startup.c main.c mfx.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c storage.c system_stm32l4xx.c
  group Application/User/STemWin
    ../Gui/App/: MenuLauncher.c
  group Application/User/STemWin/generated
    ../Gui/App/generated/: background.c dialog_box.c info_screen.c message_box.c pbar_bck.c stemwin_icon.c tara_icon.c touchgfx_icon.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval.c stm32l4r9i_eval_io.c stm32l4r9i_eval_ospi_nor.c stm32l4r9i_eval_rgb_ts.c stm32l4r9i_eval_sd.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_nor.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_ll_fmc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c stm32l4xx_hal_uart_ex.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Core/Src/: sd_diskio_dma.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/STemWin/Library
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM4_OS_wc32_ot_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: cancel.c ok.c STM32L4R9I_EVAL_STemWin_Addons_5.40_Keil.lib up.c
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c LCDConf_bba.c
target MenuLauncher-STM32L4R9I-EVAL_MB1315_OoB (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: STMicroelectronics.STM32L4xx_DFP.1.0.1
  cpu: as above
  output: MenuLauncher-STM32L4R9I-EVAL_MB1315_OoB_V1.0.0
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --wchar32
  c include: ../Config;../Core/Inc;../Gui/Target;../Gui/App/generated;../Gui/STemWin_Addons;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4R9I_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/ft5336;../../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../../Drivers/BSP/Components/iss66wvh8m8;../../../../../../Drivers/BSP/Components/mx25lm51245g;../../../../../../Middlewares/ST/STemWin/inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x20000000 size 0xa0000
software components: CMSIS:CORE 4.3.0
