<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>Project</project>
        <configuration>MenuLauncher-STM32L4R9I-EVAL_MB1314</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>MenuLauncher-STM32L4R9I-EVAL_MB1314_OoB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


