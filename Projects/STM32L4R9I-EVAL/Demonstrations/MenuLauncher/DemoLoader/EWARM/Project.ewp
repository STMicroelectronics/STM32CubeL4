# IAR project Project.ewp, settings and files
configuration DemoLoader-STM32L4R9I-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4R9xx; USE_IOEXPANDER; USE_UART_TRACES
  ICCARM.CCIncludePath2: ..\Config; ..\Core\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4R9I_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\ft5336; ..\..\..\..\..\..\Drivers\BSP\Components\iss66wvh8m8; ..\..\..\..\..\..\Drivers\BSP\Components\ft3x67
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DemoLoader-STM32L4R9I-EVAL_V1.0.0.hex
  ILINK.IlinkOutputFile: DemoLoader-STM32L4R9I-EVAL_V1.0.0.out
  ILINK.IlinkIcfFile: STM32L4R9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l4r9xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft3x67/: ft3x67.c
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval.c stm32l4r9i_eval_io.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
