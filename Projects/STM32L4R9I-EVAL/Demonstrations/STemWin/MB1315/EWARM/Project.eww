<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>everything</name>
      <member>
        <project>Project</project>
        <configuration>STemWin-STM32L4R9I-EVAL_MB1315</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>STemWin-STM32L4R9I-EVAL_MB1315_OoB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


