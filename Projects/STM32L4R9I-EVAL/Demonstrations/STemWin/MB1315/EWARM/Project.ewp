# IAR project Project.ewp, settings and files
configuration STemWin-STM32L4R9I-EVAL_MB1315 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L4R9xx; USE_ROCKTECH_480x272; USE_IOEXPANDER; USE_OSPI_NOR=1; USE_OSPI_RAM=0; USE_USB_DISK=0; BSP_USE_CMSIS_OS
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Config; ..\Gui\Target; ..\Gui\STemWin_Addons; ..\Modules\Common; ..\Modules\audio_player; ..\Modules\audio_player\Addons\Common\Inc; ..\Modules\audio_player\Addons\GREQ\Inc; ..\Modules\audio_player\Addons\BIQ\Inc; ..\Modules\audio_recorder; ..\Modules\usbdevice; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4R9I_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\ft5336; ..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152; ..\..\..\..\..\..\Drivers\BSP\Components\iss66wvh8m8; ..\..\..\..\..\..\Drivers\BSP\Components\mx25lm51245g; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc; ..\..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STemWin-STM32L4R9I-EVAL_MB1315_V1.0.0.hex
  ILINK.IlinkOutputFile: STemWin-STM32L4R9I-EVAL_MB1315_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08000000
  ILINK.IlinkIcfFile: STM32L4R9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STemWin-STM32L4R9I-EVAL_MB1315_OoB (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: STemWin-STM32L4R9I-EVAL_MB1315_OoB_V1.0.0.hex
  ILINK.IlinkOutputFile: STemWin-STM32L4R9I-EVAL_MB1315_OoB_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08080000
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  group Application/EWARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l4r9xx.s
  group Application/User/Core
    ../Core/Src/: k_bsp.c k_menu.c k_mfx.c k_module.c k_rtc.c k_storage.c main.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c system_stm32l4xx.c
  group Application/User/Modules/AudioPlayer
    ../Modules/audio_player/: audio_player_app.c
    ../Gui/Core/audio_player/: audio_player_win.c
  group Application/User/Modules/AudioPlayer/Addons/BIQ
    ../Modules/audio_player/Addons/BIQ/Lib/: BIQ_CM4_IAR.a
  group Application/User/Modules/AudioPlayer/Addons/GREQ
    ../Modules/audio_player/Addons/GREQ/Lib/: GrEq_CM4_IAR.a
  group Application/User/Modules/AudioPlayer/Addons/PDM
    ../Modules/audio_player/Addons/PDM/: libPDMFilter_CM4F_IAR.a
  group Application/User/Modules/AudioRecorder
    ../Modules/audio_recorder/: audio_recorder_app.c
    ../Gui/Core/audio_recorder/: audio_recorder_win.c
  group Application/User/Modules/Benchmark
    ../Gui/Core/benchmark/: benchmark_win.c
  group Application/User/Modules/Common
    ../Modules/Common/: audio_if.c
  group Application/User/Modules/Game
    ../Gui/Core/games/: games_win.c
  group Application/User/Modules/GardeningControl
    ../Gui/Core/gardening_control/: gardening_control_win.c
  group Application/User/Modules/HomeAlarm
    ../Gui/Core/home_alarme/: home_alarm_win.c
  group Application/User/Modules/Settings
    ../Gui/Core/settings/: settings_win.c
  group Application/User/Modules/USBDevice
    ../Modules/usbdevice/: usbd_app.c usbd_desc.c usbd_storage.c
    ../Gui/Core/usbdevice/: usbd_win.c
  group Application/User/Utilities
    ../../../../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../: ReadMe.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32L4R9I_EVAL
    ../../../../../../Drivers/BSP/STM32L4R9I_EVAL/: stm32l4r9i_eval.c stm32l4r9i_eval_audio.c stm32l4r9i_eval_io.c stm32l4r9i_eval_ospi_nor.c stm32l4r9i_eval_ospi_ram.c stm32l4r9i_eval_rgb_ts.c stm32l4r9i_eval_sd.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_nor.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_ll_fmc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Config/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STemWin/Library
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM4_OS_wc16.a
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STM32L4R9I_EVAL_STemWin_Addons_5.40_IAR.a
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/USBD_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/USBD_Library/Config
    ../Config/: usbd_conf.c
  group Middlewares/USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
