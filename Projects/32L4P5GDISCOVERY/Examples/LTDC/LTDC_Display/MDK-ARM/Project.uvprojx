# Keil uVision project Project.uvprojx, settings and files
target STM32L4P5xx (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L4P5AGIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.2
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2004FFFF) IRAM2(0x20000000-0x2001FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32L4P5xx,USE_HAL_DRIVER,USE_STM32L4P5xx
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4P5G-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4P5G-Discovery
    ../../../../../../Drivers/BSP/STM32L4P5G-Discovery/: stm32l4p5g_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Example/MDK-ARM
    ./: startup_stm32l4p5xx.s
  group Example/User
    ../Src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
software components: CMSIS:CORE 4.3.0
