# Keil uVision project Project.uvprojx, settings and files
target STM32L476RG_NUCLEO (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.0.0.3
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476RG_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L476xx,USE_STM32L4XX_NUCLEO,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_LL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c stm32l4xx_ll_dac.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
software components: CMSIS:CORE 4.1.0
