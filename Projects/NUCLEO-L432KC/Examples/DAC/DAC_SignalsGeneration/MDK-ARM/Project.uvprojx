# Keil uVision project Project.uvprojx, settings and files
target STM32L432KC_NUCLEO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x08000000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32L432KC_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L432xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L4xx_Nucleo_32;../../../../../../Drivers/BSP/Components/stmpe811;../../../../../../Drivers/BSP/Components/stmpe1600
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32l432xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo_32
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo_32/: stm32l4xx_nucleo_32.c
  group Example/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_dac.c stm32l4xx_hal_uart.c stm32l4xx_hal_pwr.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
software components: CMSIS:CORE 4.3.0
