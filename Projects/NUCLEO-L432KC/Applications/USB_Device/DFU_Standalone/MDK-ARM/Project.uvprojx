# Keil uVision project Project.uvprojx, settings and files
target STM32L432KC_NUCLEO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x08000000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32L432KC_NUCLEO
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L432xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/STM32L4xx_Nucleo_32;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/MDK-ARM
    ./: startup_stm32l432xx.s
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo_32/: stm32l4xx_nucleo_32.c
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c usbd_desc.c stm32l4xx_it.c usbd_dfu_flash.c usbd_conf.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_spi.c stm32l4xx_hal_uart.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_pcd.c stm32l4xx_ll_usb.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c
software components: CMSIS:CORE 4.3.0
