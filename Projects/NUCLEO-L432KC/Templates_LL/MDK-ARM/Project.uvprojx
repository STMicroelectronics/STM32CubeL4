# Keil uVision project Project.uvprojx, settings and files
target STM32L432KC_NUCLEO (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.2
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32L432KC_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L432xx,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Drivers/STM32L4xx_LL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_crc.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_usart.c stm32l4xx_ll_pwr.c stm32l4xx_ll_utils.c stm32l4xx_ll_spi.c stm32l4xx_ll_opamp.c stm32l4xx_ll_rcc.c stm32l4xx_ll_lptim.c stm32l4xx_ll_adc.c stm32l4xx_ll_dac.c stm32l4xx_ll_rng.c stm32l4xx_ll_crs.c stm32l4xx_ll_exti.c stm32l4xx_ll_rtc.c stm32l4xx_ll_tim.c stm32l4xx_ll_comp.c stm32l4xx_ll_gpio.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_i2c.c stm32l4xx_ll_dma.c
  group Example/MDK-ARM
    ./: startup_stm32l432xx.s
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
software components: CMSIS:CORE 4.3.0
